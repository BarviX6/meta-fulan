require fulan-dvb-modules.inc

PR = "${INC_PR}"

SRCDATE = "20210318"

COMPATIBLE_MACHINE = "spark7162"
