require fulan-dvb-modules.inc

PR = "${INC_PR}"

SRCDATE = "20210423"

COMPATIBLE_MACHINE = "spark"
